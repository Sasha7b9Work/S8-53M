# Keil uVision project Device.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: S8-53
  AfterMake: fromelf --bin --output .\S8-53.bin .\Objects-Debug\s8-53.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus,DEBUG,DEVICE
  c misc: --cpp
  c include: ..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Src;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Src;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Device_Library\Core\Src;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Src;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Src;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src\include;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\system;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src\include\ipv4;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src\drivers;.\src;.\src\Hardware\HAL;..\STM32Cube_FW_F4\Middlewares\Third_Party\LwIP\src\include\lwip;..\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\..\sources;.\src\Hardware\VCP;.\src\Hardware\LAN;.\src\Hardware\FDrive
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\S8-53.sct
  group HAL
    ../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hcd.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_ll_fmc.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_ltdc.c
  group FatFS
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group USBD
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group USBH
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group LwIP
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/core/: udp.c tcp_in.c tcp_out.c tcp.c raw.c sys.c stats.c pbuf.c memp.c netif.c init.c mem.c inet_chksum.c dns.c def.c ip.c timeouts.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/core/ipv4/: igmp.c ip4.c ip4_addr.c autoip.c icmp.c dhcp.c etharp.c ip4_frag.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/api/: tcpip.c sockets.c netdb.c err.c netbuf.c api_lib.c api_msg.c
    ../STM32Cube_FW_F4/Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
  group src
    ./src/: check.bat defines.h GlobalEvents.cpp GlobalEvents.h globals.cpp globals.h Log.cpp Log.h main.cpp main.h main2.s
  group Data
    ./src/Data/: Measures.h Measures.cpp Storage.h Storage.cpp Processing.h Processing.cpp Data.h Data.cpp DataExtensions.h DataExtensions.cpp
  group Display
    ./src/Display/: Colors.cpp Colors.h DataPainter.cpp DataPainter.h Display.cpp Display.h DisplayTypes.h Painter.cpp Painter.h
  group Display/font
    ./src/Display/font/: Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc Font.cpp
  group Display/Screen
    ./src/Display/Screen/: HiPart.cpp HiPart.h Console.cpp Console.h Grid.cpp Grid.h LowPart.cpp LowPart.h
  group FPGA
    ./src/FPGA/: AutoFinder.cpp CalibrationFPGA.cpp FPGA.h FPGA.cpp FreqMeter.cpp ReaderFPGA.cpp SettingsFPGA.h SettingsFPGA.cpp StructuresFPGA.h StructuresFPGA.cpp TypesFPGA.h
  group Hardware
    ./src/Hardware/: Sound.cpp Sound.h Timer.h Timer.cpp InterCom.h ExternalGenerator.cpp ExternalGenerator.h InterCom.cpp
  group Hardware/FDrive
    ./src/Hardware/FDrive/: FDrive.cpp FDrive.h ffconf.h usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group Hardware/HAL
    ./src/Hardware/HAL/: HAL.h HAL_PINS.h HAL_ROM.h HAL_PINS.cpp HAL.cpp HAL_IT.cpp HAL_ADC1.cpp HAL_CRC32.cpp HAL_DAC1.cpp HAL_DAC2.cpp HAL_FMC.cpp HAL_LTDC.cpp HAL_ROM.cpp HAL_SPI1.cpp HAL_SPI5.cpp HAL_RTC.cpp HAL_TIM2.cpp HAL_TIM6.cpp HAL_TIM7.cpp startup_stm32f429xx.s stm32f4xx_hal_conf.h system_stm32f4xx.c
  group Hardware/LAN
    ./src/Hardware/LAN/: app_ethernet.h ethernetif.h lwipopts.h LAN.cpp LAN.h app_ethernet.cpp ethernetif.cpp
  group Hardware/VCP
    ./src/Hardware/VCP/: USBD.cpp USBD.h usbd_cdc_interface.cpp usbd_cdc_interface.h usbd_conf.cpp usbd_conf.h usbd_desc.cpp usbd_desc.h VCP.cpp VCP.h
  group Menu
    ./src/Menu/: FileManager.h Menu.cpp Menu.h MenuItems.cpp MenuItems.h MenuFunctions.cpp MenuDrawing.cpp FileManager.cpp MenuItemsGraphics.cpp MenuItemsLogic.cpp
  group Menu/Pages
    ./src/Menu/Pages/: Definition.h HelpContent.h HelpContentPages.h PageCursors.cpp Definition.cpp PageService.cpp PageDebug.cpp HelpContent.cpp PageChannels.cpp PageDisplay.cpp PageHelp.cpp PageMeasures.cpp PageTime.cpp PageTrig.cpp
  group Menu/Pages/PageMemory
    ./src/Menu/Pages/PageMemory/: PageMemory.cpp PageMemoryLatest.cpp PageMemoryExternal.cpp PageMemoryInternal.cpp PageMemoryFIleManager.cpp PageMemorySetMask.cpp PageMemorySetName.cpp loses.cpp PageMemoryResolver.cpp
  group Panel
    ./src/Panel/: Panel.h Panel.cpp
    ../common/Panel/: Controls.h Controls.cpp
  group SCPI
    ./src/SCPI/: channelSCPI.cpp commonSCPI.cpp controlSCPI.cpp displaySCPI.cpp SCPI.cpp SCPI.h tbaseSCPI.cpp trigSCPI.cpp BufferSCPI.cpp BufferSCPI.h
  group Settings
    ./src/Settings/: SettingsTypes.h Settings.h SettingsChannel.h SettingsDisplay.h SettingsMemory.h SettingsTime.h SettingsService.h SettingsCursors.h SettingsTrig.h SettingsMath.h Settings.cpp SettingsChannel.cpp SettingsCursors.cpp SettingsDisplay.cpp SettingsMeasures.h SettingsNRST.h SettingsNRST.cpp
  group Utils
    ./src/Utils/: CreateTables.py Debug.h Debug.cpp Generator.h Generator.cpp Math.h Math.cpp Mutex.h PasswordResolver.h PasswordResolver.cpp TablesLog.h TablesWindow.h
  group Utils/Containers
    ./src/Utils/Containers/: Queue.h Buffer.h Values.cpp Values.h
  group Utils/Text
    ./src/Utils/Text/: String.cpp String.h Symbols.h Tables.cpp Tables.h Text.cpp Text.h Warnings.cpp Warnings.h
target Release (5060960::V5.06 update 7 (build 960)::.\ARMCC_536_5_06_7)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: S8-53
  AfterMake: fromelf --bin --output .\S8-53.bin .\Objects\s8-53.axf
  c flags: Optim=4 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F429xx, __cplusplus,DEVICE,USE_FULL_LL_DRIVER
  c misc: --cpp --diag_suppress 4487
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\S8-53.sct
