# Keil uVision project Loader.uvprojx, settings and files
target Release (6240000::V6.24::ARMCLANG)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Loader +hex
  c flags: Optim=4 oTime=1 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=1
  c define: USE_HAL_DRIVER, STM32F429xx, LOADER
  c include: .\src\Hardware\FDrive;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\Hardware\HAL;.\src;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src;.\src\Hardware\FDrive
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Loader.sct
  group libs/CMSIS
    ../common/STM32Cube_F4/Drivers/CMSIS/Include/: cmsis_armcc.h cmsis_compiler.h cmsis_version.h mpu_armv7.h
  group libs/FatFS
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff_gen_drv.h ff.c ff.h diskio.c diskio.h
    ../STM32Cube_FW_F4/Middlewares/Third_Party/FatFs/src/option/: syscall.c unicode.c
  group libs/HAL
    ../STM32Cube_FW_F4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dac.c stm32f4xx_hal_tim.c stm32f4xx_hal_hcd.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_sram.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_usb.c stm32f4xx_ll_fmc.c
  group libs/USBH
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Class/MSC/Src/: usbh_msc.c usbh_msc_bot.c usbh_msc_scsi.c
    ../STM32Cube_FW_F4/Middlewares/ST/STM32_USB_Host_Library/Core/Src/: usbh_core.c usbh_ctlreq.c usbh_ioreq.c usbh_pipes.c
  group Hardware
    ./src/Hardware/: FLASH.h Timer.cpp Timer.h
  group Hardware/CMSIS
    ./src/Hardware/CMSIS/: startup_stm32f429xx.s system_stm32f4xx.c
  group Hardware/Memory
    ./src/Hardware/Memory/: ROM.h Sector.cpp Sector.h
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h
  group Hardware/HAL
    ./src/Hardware/HAL/: stm32f4xx_hal_conf.h HAL.h HAL_PINS.h HAL_DAC1.cpp HAL_FMC.cpp HAL_LTDC.cpp HAL_ROM.cpp HAL_TIM2.cpp HAL_TIM2.h HAL_TIM6.cpp HAL.cpp HAL_IT.cpp HAL_PINS.cpp HAL_ROM_stm.cpp
  group Hardware/FDrive
    ./src/Hardware/FDrive/: FDrive.cpp FDrive.h ffconf.h USBH.cpp USBH.h usbh_conf.cpp usbh_conf.h usbh_diskio.cpp usbh_diskio.h
  group src
    ./src/: defines.cpp defines.h main.cpp main.h defines_.h Log.cpp Log.h redefine_hal.h
  group Display
    ./src/Display/: Display.h Display.cpp Colors.cpp Colors.h Colors_stm.cpp Console.h Display_stm.cpp
  group Display/Font
    ./src/Display/Font/: Font.cpp Font.h font5.inc font5display.inc font8.inc font8display.inc fontUGO.inc fontUGO2.inc fontUGO2display.inc fontUGOdisplay.inc
  group Display/Painter
    ./src/Display/Painter/: Painter.cpp Painter.h Primitives.cpp Primitives.h Primitives_stm.cpp Text.cpp Text.h Animated.cpp Animated.h
  group Panel
    ./src/Panel/: Panel.h Panel.cpp Controls.h
  group Settings
    ./src/Settings/: Settings.h Settings.cpp
  group Utils
    ./src/Utils/: Math.cpp Math.h StringUtils.cpp StringUtils.h
  group Utils/Containers
    ./src/Utils/Containers/: Buffer.cpp Buffer.h String.cpp String.h Values.cpp Values.h
target Debug (6240000::V6.24::ARMCLANG)
  device: STM32F429IITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: DLoader +hex
  c flags: Optim=2 OneElfS=1 v6Lang=6 v6LangP=9 wLevel=1
  c define: USE_HAL_DRIVER, STM32F429xx, LOADER, DEBUG
  c include: ..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;..\STM32Cube_FW_F4\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\STM32Cube_FW_F4\Drivers\CMSIS\Include;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Core\Inc;..\STM32Cube_FW_F4\Middlewares\ST\STM32_USB_Host_Library\Class\MSC\Inc;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src;..\STM32Cube_FW_F4\Middlewares\Third_Party\FatFs\src\drivers;.\src\Hardware\FDrive;..\STM32Cube_FW_F4\Drivers\STM32F4xx_HAL_Driver\Inc;.\src\Hardware\HAL;.\src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Loader.sct
